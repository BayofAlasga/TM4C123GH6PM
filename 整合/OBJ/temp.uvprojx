# Keil uVision project temp.uvprojx, settings and files
target LCD (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: temp
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: PART_TM4C123GH6PM, TARGET_IS_BLIZZARD_RB1
  c include: ..\..\TEMPLATE;..\CORE;..\USER;..\LIB;..\LIB\driverlib;..\LIB\inc;..\LIB\utils;..\USER\User_party\AD9854;..\USER\User_party\ADC;..\USER\User_party\ADS1256;..\USER\User_party\DAC7612;..\USER\User_party\DMA;..\USER\User_party\include;..\USER\User_party\key;..\USER\User_party\LED;..\USER\User_party\timer;..\USER\User_party\tm4c_ps2_lcd;..\USER\User_party\usart;..\USER\User_party\AD9959;..\USER\User_party\pcf8574;..\USER\User_party\74HC595;..\USER\User_party\x9c104
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CORE
    ../CORE/: startup_rvmdk.S
  group LIB
    ../LIB/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group USER
    ./: main.c
    ../USER/: uc1701.c
    ../USER/User_party/AD9854/: bsp_ad9854.c
    ../USER/User_party/ADC/: bsp_adc.c
    ../USER/User_party/ADS1256/: bsp_ads1256.c
    ../USER/User_party/DAC7612/: bsp_dac.c
    ../USER/User_party/DMA/: bsp_dma.c
    ../USER/User_party/include/: bsp_include.c
    ../USER/User_party/key/: bsp_key.c
    ../USER/User_party/LED/: bsp_led.c
    ../USER/User_party/timer/: bsp_tim.c
    ../USER/User_party/tm4c_ps2_lcd/: font.c ps2_driver_tm4c.c ps2_keyboardtable.c ps2_LCD.c
    ../USER/User_party/usart/: bsp_usart.c
    ../USER/User_party/AD9959/: bsp_ad9959.c
    ../USER/User_party/pcf8574/: bsp_pcf8574.c
    ../USER/User_party/74HC595/: bsp_74hc595.c
    ../USER/User_party/x9c104/: bsp_x9c104.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
